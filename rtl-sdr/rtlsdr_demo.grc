options:
  parameters:
    author: Daniel
    generate_options: qt_gui
    id: rtlsdr_demo
    output_language: python
    title: RTL-SDR demo
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '10'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 98.8e6
  states: {}
- name: if_gain
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '20'
  states: {}
- name: rf_gain
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: rf_gain
    freq0: frequency
    gain0: bb_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: frequency
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
