options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: spectral_analysis_voyager1
    output_language: python
    title: Spectral Analysis (Voyager 1)
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: integration_seconds
  id: variable
  parameters:
    value: '1'
  states: {}
- name: integration_seconds2
  id: variable
  parameters:
    value: '3'
  states: {}
- name: integrations
  id: variable
  parameters:
    value: int(np.round(samp_rate / nfft * integration_seconds))
  states: {}
- name: integrations2
  id: variable
  parameters:
    value: int(np.round(samp_rate / (decimation * nfft) * integration_seconds))
  states: {}
- name: lowpass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 0.45 * samp_rate / decimation
    gain: '1.0'
    samp_rate: samp_rate
    width: 0.05 * samp_rate / decimation
    win: window.WIN_HAMMING
  states: {}
- name: nfft
  id: variable
  parameters:
    value: 2**16
  states: {}
- name: nfft2
  id: variable
  parameters:
    value: 2**16
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.9296875e6
  states: {}
- name: signal_frequency
  id: variable
  parameters:
    value: '-379e3'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft2
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/vgr1_blc23_guppi_59046_80036_DIAG_VOYAGER-1_0011.cs8
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: integrations
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: integrations2
    type: float
    vlen: nfft2
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '128'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/integrations] * nfft'
    type: float
    vlen: nfft
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/integrations2] * nfft2'
    type: float
    vlen: nfft2
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nfft2
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
    vlen: nfft
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
    vlen: nfft2
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft2
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: nfft2
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: signal_frequency
    decim: decimation
    samp_rate: samp_rate
    taps: lowpass_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: Full spectrum (frequency sink)
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: signal_frequency
    fftsize: '4096'
    name: Spectrum around signal (frequency sink)
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: Full spectrum (our spectrometer)
    vlen: nfft
    x_axis_label: '"Frequency (Hz)"'
    x_start: '-samp_rate/2'
    x_step: samp_rate/nfft
    y_axis_label: '"PSD (dB)"'
    ymax: '55'
    ymin: '30'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    name: Spectrum around signal (our spectrometer)
    vlen: nfft2
    x_axis_label: '"Frequency (Hz)"'
    x_start: '-samp_rate/(2 * decimation) + signal_frequency'
    x_step: samp_rate/(nfft2 * decimation)
    y_axis_label: '"PSD (dB)"'
    ymax: '45'
    ymin: '10'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: decimated_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: decimated_signal
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_repeat_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_repeat_0_0, '0']
- [blocks_repeat_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_repeat_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_0_0, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
