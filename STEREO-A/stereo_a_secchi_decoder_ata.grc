options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: stereo_a_secchi_decoder_ata
    output_language: python
    title: STEREO-A SECCHI decoder
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''''.join([str(i) for i in (syncword+1)//2])[-64:]'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '3800'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '8'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 512e6
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 480e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/(baudrate * decim)
  states: {}
- name: syncword
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''25D5C0CE8990F6C9461BF79CDA2A3F31766F0936B9E40863'''
  states: {}
- name: turbo_octets
  id: variable
  parameters:
    value: '5'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '3.14'
    min_freq: '-3.14'
    w: 2*3.14*pll_bw/samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: frames.u8
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: stereo-a_480ksps.ci16
    type: short
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.01'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: dslwp_ccsds_pseudo_randomizer_0
  id: dslwp_ccsds_pseudo_randomizer
  parameters:
    data_format: '3'
  states: {}
- name: dslwp_ccsds_turbo_decode_0
  id: dslwp_ccsds_turbo_decode
  parameters:
    base: '223'
    code_type: '6'
    iterations: '10'
    octets: turbo_octets
    sigma: '0.707'
    update_sigma: '0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pathlib
      import struct
      import subprocess
      import warnings

      import numpy as np
      import matplotlib.pyplot as plt
      from gnuradio import gr
      import pmt
      from construct import *


      TMPrimaryHeader = BitStruct(
          'transfer_frame_version_number' / BitsInteger(2),
          'spacecraft_id' / BitsInteger(10),
          'virtual_channel_id' / BitsInteger(3),
          'ocf_flag' / Flag,
          'master_channel_frame_count' / BitsInteger(8),
          'virtual_channel_frame_count' / BitsInteger(8),
          'secondary_header_flag' / Flag,
          'synch_flag' / Flag,
          'packet_order_flag' / Flag,
          'segment_length_id' / BitsInteger(2),
          'first_header_pointer' / BitsInteger(11)
      )

      SpacePacketPrimaryHeader = BitStruct(
          'ccsds_version' / BitsInteger(3),
          'packet_type' / BitsInteger(1),
          'secondary_header_flag' / Flag,
          'APID' / BitsInteger(11),
          'sequence_flags' / BitsInteger(2),
          'packet_sequence_count_or_name' / BitsInteger(14),
          'data_length' / BitsInteger(16)
      )

      SECCHIBlockHeader = BitStruct(
          'padding' / Padding(5),
          'image_count' / BitsInteger(11),
          'block_type' / BitsInteger(2),
          'block_number' / BitsInteger(14),
          'block_length' / BitsInteger(16)
      )


      class SecchiExtractor:
          def __init__(self, apid, output_dir):
              self.apid = apid
              self.output_dir = pathlib.Path(output_dir)
              self.block = bytearray()
              self.seq_count = None

          def process_packet(self, packet):
              packet_header = SpacePacketPrimaryHeader.parse(packet)
              seq_count_new = packet_header.packet_sequence_count_or_name
              if self.seq_count is not None \
                and seq_count_new != ((self.seq_count + 1) % 2**14):
                  warnings.warn(f'[SECCHI block extractor APID {self.apid}] '
                                'Broken stream. '
                                f'Last seq count {self.seq_count}, '
                                f'current seq count {seq_count_new}')
                  self.block = bytearray()
              self.seq_count = seq_count_new

              first = struct.unpack('>H', packet[12:14])[0]
              if first == 0x7ff:
                  # no packet starts
                  if self.block:
                      self.block.extend(packet[14:])
                  return
              
              if self.block:
                  self.block.extend(packet[14:][:first])
                  self.block = bytes(self.block)
                  if self.check_secchi_block():
                      self.process_block()

              while True:
                  self.block = bytearray(packet[14:][first:][:SECCHIBlockHeader.sizeof()])
                  if len(self.block) < SECCHIBlockHeader.sizeof():
                      # not full block header inside frame
                      return
                  first += SECCHIBlockHeader.sizeof()
                  block_header = SECCHIBlockHeader.parse(self.block)
                  self.block.extend(packet[14:][first:][:block_header.block_length + 1])
                  first += block_header.block_length + 1
                  if first > len(packet[14:]):
                      # block does not end in this frame
                      return
                  self.block = bytes(self.block)
                  if self.check_secchi_block():
                      self.process_block()
                  self.block = bytearray()
                  if first == len(packet[14:]):
                      # block just ends in this frame
                      return

          def check_secchi_block(self):
              if len(self.block) < SECCHIBlockHeader.sizeof():
                  warnings.warn('SECCHI block too short')
                  return False
              header = SECCHIBlockHeader.parse(self.block)
              expected = header.block_length + 1 + SECCHIBlockHeader.sizeof()
              if len(self.block) != expected:
                  warnings.warn(f'SECCHI block has incorrect size. Expected {expected}; '
                                f'has {len(block)}')
                  return False
              return True

          def process_block(self):
              header = SECCHIBlockHeader.parse(self.block)
              print(f'[APID {self.apid}] received SECCHI block: {header}')
              if header.block_type != 0 or header.image_count == 2047:
                  return
              if self.apid == 1139:
                  # apparently APID 1139 (HI2) is compressed with rice instead of
                  # icer, so we just write the compressed image
                  output_path = str(self.output_dir
                                    / (f'SECCHI_APID{self.apid}_'
                                       f'{header.image_count}_compressed.raw'))
                  with open(output_path, 'wb') as f:
                      f.write(self.block[SECCHIBlockHeader.sizeof():])
                  return
              with open('/tmp/secchi_compressed', 'wb') as f:
                  f.write(self.block[SECCHIBlockHeader.sizeof():])
                  output_path = str(self.output_dir
                                    / (f'SECCHI_APID{self.apid}_'
                                       f'{header.image_count}.raw'))
                  output_png = str(self.output_dir
                                    / (f'SECCHI_APID{self.apid}_'
                                       f'{header.image_count}.png'))
                  subprocess.run(['./idecomp.linux', '-i', '/tmp/secchi_compressed',
                                  '-o', output_path])
                  img = np.fromfile(output_path, 'uint16')
                  size = int(np.sqrt(img.size))
                  img = img.reshape(size, size).T
                  vertical_flip = self.apid in [1140]
                  if vertical_flip:
                      img = img[::-1]
                  plt.figure(figsize=(5, 5))
                  plt.imshow(img, cmap='inferno', vmin=0, vmax=np.max(img))
                  plt.savefig(output_png)


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, output_dir='/tmp/'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='STEREO-A SECCHI Decoder',   # will show up in GRC
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.handle_msg)
              self.secchi_extractors = {apid: SecchiExtractor(apid, output_dir)
                                        for apid in range(1136, 1141)}

          def handle_msg(self, msg_pmt):
              msg = pmt.cdr(msg_pmt)
              frame = np.array(pmt.u8vector_elements(msg), 'uint8')
              tm_header = TMPrimaryHeader.parse(frame)
              vcid = tm_header.virtual_channel_id
              if vcid != 7:
                  # VCID 7 is the one containing SECCHI data
                  return
              # Frames in virtual channel 7 contain 4 Space Packets with a length of
              # 272 bytes (which divides the transfer frame data field evenly in 4)
              data_field = frame[6+15:-6]
              packets = data_field.reshape(4, 272)
              for packet in packets:
                  packet_header = SpacePacketPrimaryHeader.parse(packet)
                  apid = packet_header.APID
                  if apid in self.secchi_extractors:
                      self.secchi_extractors[apid].process_packet(packet)
    output_dir: '''output'''
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*int(round(sps))'
    type: ccc
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword[::-1]/syncword.size
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: baudrate
    decim: '1'
    samp_rate: samp_rate / decim
    taps: firdes.low_pass(1, samp_rate / decim, baudrate, baudrate*0.1)
    type: fcf
  states: {}
- name: gaindB
  id: parameter
  parameters:
    label: rx gain in decibels
    short_id: g
    type: eng_float
    value: '45'
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.5 / decim * samp_rate
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 0.1 / decim * samp_rate
    win: window.WIN_HAMMING
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,1,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,1,1,1
    label1: I
    label2: Q
    name: PLL output
    nconnections: '2'
    type: float
    ymax: '-60'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0,1,1
    legend: 'False'
    name: PLL input
    type: complex
    ymax: '-60'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,1
    label1: I
    label2: Q
    name: ASM correlation
    size: (8920+4+32)*6*2
    srate: baudrate
    type: complex
  states: {}
- name: satellites_crc_check_0
  id: satellites_crc_check
  parameters:
    final_xor: '0x0'
    initial_value: '0xFFFF'
    input_reflected: 'False'
    num_bits: '16'
    poly: '0x1021'
    result_reflected: 'False'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {state: disabled}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-3'
    reference: '1.0'
  states: {}
- name: satellites_sync_to_pdu_soft_0
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: (223*8*turbo_octets+4)*6
    sync: access_code
    threshold: '12'
  states: {}
- name: satellites_sync_to_pdu_soft_0_0
  id: satellites_sync_to_pdu_soft
  parameters:
    packlen: (223*8*turbo_octets+4)*6
    sync: access_code
    threshold: '12'
  states: {}
- name: uhd_usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: fc
    clock_source0: external
    dev_addr: '"addr0=10.11.1.20"'
    dev_args: '""'
    gain0: gaindB
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: phase_mod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: phase_mod
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_0, '1']
- [blocks_complex_to_float_0, '1', virtual_sink_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_1, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', satellites_sync_to_pdu_soft_0, '0']
- [blocks_multiply_const_vxx_0, '0', satellites_sync_to_pdu_soft_0_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', fir_filter_xxx_1_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [dslwp_ccsds_pseudo_randomizer_0, out, dslwp_ccsds_turbo_decode_0, in]
- [dslwp_ccsds_turbo_decode_0, out, satellites_crc_check_0, in]
- [fir_filter_xxx_0, '0', satellites_rms_agc_0, '0']
- [fir_filter_xxx_1_0, '0', qtgui_time_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', fir_filter_xxx_0, '0']
- [low_pass_filter_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [satellites_crc_check_0, ok, epy_block_0, in]
- [satellites_crc_check_0, ok, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_crc_check_0, ok, satellites_hexdump_sink_0, in]
- [satellites_rms_agc_0, '0', digital_symbol_sync_xx_0, '0']
- [satellites_sync_to_pdu_soft_0, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [satellites_sync_to_pdu_soft_0_0, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [uhd_usrp_source, '0', analog_pll_carriertracking_cc_0, '0']
- [uhd_usrp_source, '0', blocks_complex_to_interleaved_short_0, '0']
- [uhd_usrp_source, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
