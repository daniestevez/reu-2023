options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: spectral_analysis_hi_line
    output_language: python
    title: Spectral Analysis (HI line)
  states: {}

blocks:
- name: integration_seconds
  id: variable
  parameters:
    value: '100'
  states: {}
- name: integrations
  id: variable
  parameters:
    value: int(np.round(samp_rate / nfft * integration_seconds))
  states: {}
- name: nfft
  id: variable
  parameters:
    value: 2**12
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/reu-2023/spectral-analysis/w3oh/W3OH_1665MHz_2022-06-21T19_36_55_pol_x.sigmf-data
    repeat: 'True'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/reu-2023/spectral-analysis/w3oh/W3OH_1665MHz_2022-06-21T19_36_55_pol_y.sigmf-data
    repeat: 'True'
    type: short
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: integrations
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: integrations
    type: float
    vlen: nfft
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15 * 1.4
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/integrations] * nfft'
    type: float
    vlen: nfft
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/integrations] * nfft'
    type: float
    vlen: nfft
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
    vlen: nfft
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: '100'
    type: float
    vlen: nfft
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*100
    type: complex
  states: {state: bypassed}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    nconnections: '2'
    vlen: nfft
    x_axis_label: '"Frequency (Hz)"'
    x_start: '-samp_rate/2'
    x_step: samp_rate/nfft
    y_axis_label: '"PSD (dB)"'
    ymax: '0.07'
    ymin: '0.05'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal0
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: signal1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: signal0
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: signal1
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', virtual_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_repeat_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_repeat_0_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0_0, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
