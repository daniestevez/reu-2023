options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: doppler_simulation
    output_language: python
    title: Doppler simulation (Doppler correction block)
  states: {}

blocks:
- name: cn0_db
  id: variable
  parameters:
    value: '30'
  states: {}
- name: output_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: pll_bandwidth
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: np.sqrt(samp_rate/10**(cn0_db/10))
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: np.pi
    min_freq: '-np.pi'
    w: 2 * np.pi * pll_bandwidth / samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/unwrapped_phase
    type: byte
    vlen: '12'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: round(samp_rate / output_rate)
    type: byte
    vlen: '12'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate * 100
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Exact 11 kHz frequency translation
    repeat: 'True'
    type: complex
    vector: np.exp(-1j * 2 * np.pi * np.arange(100) * 11 / 100)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '100000'
    srate: samp_rate
    type: float
  states: {}
- name: satellites_doppler_correction_0
  id: satellites_doppler_correction
  parameters:
    file: /tmp/doppler.txt
    samp_rate: samp_rate
    t0: '1689379200'
  states: {}
- name: satellites_phase_unwrap_0
  id: satellites_phase_unwrap
  parameters: {}
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_pll_refout_cc_0, '0', blocks_complex_to_arg_0, '0']
- [analog_pll_refout_cc_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_arg_0, '0', satellites_phase_unwrap_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_xx_0, '0', analog_pll_refout_cc_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', satellites_doppler_correction_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '1']
- [satellites_doppler_correction_0, '0', blocks_add_xx_0, '0']
- [satellites_phase_unwrap_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
